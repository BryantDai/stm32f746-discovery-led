# Keil uVision project Project.uvprojx, settings and files
target STM32746G_DISCOVERY_RCC (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G_DISCOVERY +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ..\CMSIS;..\Libraries\Inc;..\Libraries\Src;..\User;..\Bsp\led;..\Bsp\systemconfig
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group STARTUP
    ../CMSIS/: startup_stm32f746xx.s
  group CMSIS
    ../CMSIS/: system_stm32f7xx.c stm32f7xx.h
  group FWLB
    ../Libraries/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c
  group BSP
    ../Bsp/led/: bsp_led.c
    ../Bsp/systemconfig/: bsp_systemconfig.c
  group USER
    ../User/: main.c
    ../Libraries/Src/: stm32f7xx_it.c
software components: CMSIS:CORE 4.1.0
